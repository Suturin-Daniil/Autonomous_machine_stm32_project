# Keil uVision project Main_file.uvprojx, settings and files
target Main_file (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F413ZHTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x817FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Main_file +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F413xx
  c include: ../Drivers/STM32F4xx_HAL_Driver/Inc;                                                     ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                                     ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                                     ../Drivers/CMSIS/Include;                                                     .\Main_file;                                                     ..\Core\Src;                                                     ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f413xx.s
  group Application/User/Core
    ../Core/Inc/: step.h servo.h remoteControl.h Reverse.h
    ../Core/Src/: step.c servo.c remoteControl.c Reverse.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
